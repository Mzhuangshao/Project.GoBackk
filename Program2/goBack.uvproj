# Keil uVision project goBack.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H2K32U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x08FF) IROM(0-0x7FFF) CLOCK(35000000)
  output: goBack +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./User/: main.c
