# Keil uVision project new.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: new +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USERS
  group Source Group 1
    ./: STARTUP.A51
    ./USERS/: main.c
  group New Group
    ./USERS/: Key.c Uart.c
